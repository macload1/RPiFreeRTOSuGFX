# IAR project ota.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: $SIMPLELINK_MSP432_SDK_WIFI_PLUGIN_INSTALL_DIR$\source\; $SIMPLELINK_MSP432_SDK_INSTALL_DIR$\source\; $SIMPLELINK_MSP432_SDK_WIFI_PLUGIN_INSTALL_DIR$\source\third_party\mbedtls\include\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ota.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Header Files
    ../source/: CdnClient.h ota_archive.h ota_httpclient.h ota_json.h ota_lib.h
    ../source/CdnVendors/: CdnDropboxV2.h CdnGithub.h CdnVendors.h
    ../: ota.h otauser.h
  group Source Files
    ../source/: CdnClient.c ota_archive.c ota_httpclient.c ota_json.c ota_lib.c
    ../source/CdnVendors/: CdnDropboxV2.c CdnGithub.c
